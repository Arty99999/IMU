# Keil uVision project HERO_H750_2022.uvprojx, settings and files
target HERO_H750_2022 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: HERO_H750_2022 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__TARGET_FPU_VFP
  c include: ../Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../CUBOT/Cubot_algorithm;../CUBOT/Cubot_driver;../CUBOT/Cubot_modules;../CUBOT/Cubot_User_Config;../CUBOT/Cubot_vision;../CUBOT/Cubot_UI;../CUBOT/Cubot_devices;../MIddlewaves/ARM/DSP/Include;../MIddlewaves/ARM/DSP/Include/dsp;../MIddlewaves/ARM/DSP/Source/BasicMathFunctions;../MIddlewaves/ARM/DSP/Source/CommonTables;../MIddlewaves/ARM/DSP/Source/FastMathFunctions;../MIddlewaves/ARM/DSP/Source/MatrixFunctions;../MIddlewaves/ARM/DSP/Source/QuaternionMathFunctions
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User
    ../Src/: main.c gpio.c dma.c fdcan.c i2c.c memorymap.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Cubot/driver
    ../CUBOT/Cubot_driver/: drv_iic.c drv_timer.c driver_spi.c driver_counter.c
  group Cubot/devices
    ../CUBOT/Cubot_devices/: bmi088.c mpu6050.c
  group Cubot/modules
    ../CUBOT/Cubot_modules/: ins.c
  group Cubot/Algorithm
    ../CUBOT/Cubot_algorithm/: kalman_filter.c quaternions_EKF.c user_lib.c
  group User/Config
    ../CUBOT/Cubot_User_Config/: control_logic.c hardware_config.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0
